# Keil uVision project KEY.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: KEY +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source_Group;.\Header_Group
  group Source_Group
    ./Source_Group/: Delay.c LED.c main.c KEY.c
  group Header_Group
    ./Header_Group/: Delay.h LED.h KEY.h
