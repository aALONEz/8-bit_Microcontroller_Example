# Keil uVision project LEDSegmentDisplays.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: LEDSegmentDisplays +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Header_Group;.\Source_Group
  group Source_Group
    ./Source_Group/: Delay.c KEY.c LED.c main.c LEDSD.c
  group Header_Group
    ./Header_Group/: Delay.h KEY.h LED.h LEDSD.h
